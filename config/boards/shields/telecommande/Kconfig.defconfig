## config/boards/shields/telecommande/Kconfig.defconfig
```kconfig
if SHIELD_TELECOMMANDE

config ZMK_KEYBOARD_NAME
    default "Telecommande"

endif
```
